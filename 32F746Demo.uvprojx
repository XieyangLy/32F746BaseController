# Keil uVision project 32F746Demo.uvprojx, settings and files
target webServer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: 32F746Demo
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MQTT_MBEDTLS = 0,MQTT_TASK,STM32F746xx,USE_HAL_DRIVER
  c include: .\User;.\mqttInterface;.\mqttVirtualDevice;.\TouchGFX\target;.\TouchGFX\generated\fonts\include;.\TouchGFX\generated\gui_generated\include;.\TouchGFX\generated\images\include;.\TouchGFX\generated\texts\include;.\Middlewares\ST\TouchGFX\touchgfx\framework\include;.\Drivers\BSP\STM32746G-Discovery;.\TouchGFX\gui\include;.\virtualCOM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT6: RAM 0x20010000 size 0x1000
  memory RVCT9: RAM 0x20011000 size 0x3f000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./User/: main.cpp stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group mqttApp
    ./mqttInterface/: mqtt.c
    ./mqttVirtualDevice/: virtualDevice.c
  group HttpServer
    ./User/: HTTP_Server.c HTTP_Server_CGI.c
  group UsbDevice
    ./virtualCOM/: VirtualCOM.c USBD_User_CDC_ACM_0.c virtualCOMConf.h
  group WebFile
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx home.png keil.gif language.cgi lcd.cgi leds.cgi llblue.jpg logo.gif network.cgi pabb.gif system.cgi tcp.cgi xml_http.js
    Web/: Web.c
  group Drivers/BSP
    ./Drivers/BSP/Components/ft5336/: ft5336.c ft5336.h
    ./Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery.h stm32746g_discovery_qspi.c stm32746g_discovery_qspi.h stm32746g_discovery_sdram.c stm32746g_discovery_sdram.h stm32746g_discovery_ts.c stm32746g_discovery_ts.h
  group Application/user/TouchGFX/target
    ./TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp HW_Init.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7Instrumentation.cpp STM32F7TouchController.cpp
  group Application/user/Gui/generated/fonts
    ./TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp Font_verdana_10_4bpp.cpp Font_verdana_20_4bpp.cpp Font_verdana_40_4bpp.cpp FontGetters.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp
  group Application/user/Gui/generated/images
    ./TouchGFX/generated/images/src/: BitmapDatabase.cpp
    ./TouchGFX/generated/images/src/__designer/: blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp blue_progressindicators_bg_medium_circle_indicator_bg_full.cpp blue_progressindicators_fill_medium_circle_indicator_fill_full.cpp
  group Application/user/Gui/generated/images/gui
    ./TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ./TouchGFX/generated/gui_generated/src/scprocess_screen/: ScprocessViewBase.cpp
    ./TouchGFX/generated/gui_generated/src/scwelcom_screen/: ScWelcomViewBase.cpp
  group Application/user/Gui/generated/text
    ./TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/user/Gui/gui/common
    ./TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/user/Gui/gui/model
    ./TouchGFX/gui/src/model/: Model.cpp
  group Application/user/Gui/gui/scProcess
    ./TouchGFX/gui/src/scprocess_screen/: ScProcessPresenter.cpp ScProcessView.cpp
  group Application/user/Gui/gui/scWelcom
    ./TouchGFX/gui/src/scwelcom_screen/: ScWelcomPresenter.cpp ScWelcomView.cpp
  group Middlewares/TouchGFX
    D:/workSpaceEmbedded/STMicroelectronics/32F746DISCOVERY/Applications/32F746BaseController/Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
    ./Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp OSWrappers_cmsis.cpp OSWrappersRTX.cpp
  group segger
    ./User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group doc
    ./: README.md
target Mqtt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: 32F746Demo
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT6: RAM 0x20010000 size 0x1000
  memory RVCT9: RAM 0x20011000 size 0x3f000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Security:mbed TLS 2.17.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.10.0, Network:Interface:ETH 7.10.0, Network:Service:DNS Client 7.10.0, Network:Service:Web Server Compact 7.10.0, Network:Socket:BSD 7.10.0, Network:Socket:TCP 7.10.0, Network:Socket:UDP 7.10.0, USB:CORE 6.13.0, USB:Device 6.13.0, USB:Device:CDC 6.13.0, Board Support:Buttons 1.1.1, Board Support:LED 1.1.1, CMSIS Driver:Ethernet MAC 1.6.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.2.0, CMSIS Driver:MCI 1.6.0, CMSIS Driver:USB Device:Full-speed 1.10.0, CMSIS Driver:USB Device:High-speed 1.13.0, Device:STM32Cube Framework:Classic 1.2.6, Device:STM32Cube HAL:CRC 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:DMA2D 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:I2C 1.2.6, Device:STM32Cube HAL:LTDC 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:QSPI 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:SD 1.2.6, Device:STM32Cube HAL:SDRAM 1.2.6, Device:STM32Cube HAL:TIM 1.2.6, Device:STM32Cube HAL:UART 1.2.6, Device:STM32Cube HAL:USART 1.2.6, Device:Startup 1.2.2, Data Exchange:JSON:cJSON 1.7.7, IoT Client:MQTTClient-C 1.1.0, IoT Utility:MQTTPacket 1.1.0, IoT Utility:Socket:MDK Network 1.1.0
